# Keil uVision project GPIO控制.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GPIO控制 +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\Library\inc;..\Utilities\inc;..\ESP8266;..\Common;..\Algorithm\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Main
    ./: main.c startup_stm32f10x_md.s
  group Utilities
    ../Library/src/: stm32f10x_it.c
    ../Utilities/src/: lcd.c delay.c debug.c led.c usart.c ov7670.c string.c
    ./: key.c
  group Library
    ../Library/src/: stm32f10x_cec.c stm32f10x_dbgmcu.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_usart.c stm32f10x_exti.c misc.c stm32f10x_tim.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group ESP8266
    ../ESP8266/: bsp_esp8266.c
  group Common
    ../Common/: Common.c
  group Algorithm
    ../Algorithm/src/: discern.c ShowChar.c
software components: CMSIS:CORE 5.0.1
